<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430F2274.ewp</path>
    </project>
    <batchBuild />
</workspace>
